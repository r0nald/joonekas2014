# Keil uVision project K2RP_remote.uvproj, settings and files
target K2RP_Remote (ARM-ADS)
  device: STM32F415RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: K2RP_remote
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, USE_STM32F4_DISCOVERY, USE_USB_OTG_FS,STM32F4XX
  c misc: --fpu=softvfp
  c include: ..\Source;..\Libraries\CMSIS\Include;..\Libraries\Device\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\Libraries\STM32_USB_Device_Library\Core\inc;..\Libraries\STM32_USB_OTG_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_stm32f4xx.s
  group Source
    ../Source/: main.c stm32f4xx_it.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c button.c led.c drawing.c logic.c math.c power.c speaker.c st7735.c util.c xbee.c
    ../Source/Fonts/: verdana9.c verdana14.c
  group inc
    ../Source/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h usb_conf.h usbd_cdc_vcp.h usbd_conf.h usbd_desc.h button.h buttoncfg.h typedefs.h led.h ledcfg.h colors.h drawing.h logic.h main.h math.h power.h powercfg.h speaker.h speakercfg.h st7735.h st7735cfg.h util.h xbee.h xbeecfg.h
  group USB_Driver
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../Libraries/STM32_USB_OTG_Driver/inc/: usb_bsp.h usb_core.h usb_dcd.h usb_dcd_int.h usb_defines.h usb_regs.h
    ../Libraries/STM32_USB_Device_Library/Core/inc/: usbd_core.h usbd_def.h usbd_ioreq.h usbd_req.h usbd_usr.h
    ../Libraries/STM32_USB_Device_Library/Class/cdc/inc/: usbd_cdc_core.h
  group STD_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CMSIS
    ../Source/: system_stm32f4xx.c
